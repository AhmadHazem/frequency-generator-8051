# Keil uVision project Frequency_Generator_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Frequency_Generator_8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c quad_7segment.c quad_7segment.h timer0.c timer0.h Interrupt0.h Interrupt0.c
    ../../: keypad.c keypad.h
